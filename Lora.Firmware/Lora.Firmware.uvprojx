# Keil uVision project Lora.Firmware.uvprojx, settings and files
target Lora (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L151CBTx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lora.Firmware +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, HSE_VALUE=8000000
  c include: .\Libraries\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32L1xx\Include;.\inc;.\inc\GPS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group App
    ./src/: Led.c main.c Debug.c Utilities.c Interrupt.c InitSystem.c Watchdog.c Configuration.c HardwareManager.c
  group PowerCtrl
    ./src/PowerCtrl/: PowerCtrl.c
  group GPS
    ./src/GPS/: GPS_Process.c GPS_Hardware.c
  group Libraries
    ./Libraries/src/: misc.c stm32l1xx_gpio.c stm32l1xx_usart.c stm32l1xx_rcc.c stm32l1xx_iwdg.c stm32l1xx_pwr.c stm32l1xx_exti.c stm32l1xx_syscfg.c stm32l1xx_flash.c
    ./Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
    ./Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_md.s
software components: CMSIS:CORE 5.6.0
